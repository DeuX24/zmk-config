## boards/shields/btn_macro/Kconfig.defconfig
```kconfig
if SHIELD_BTN_MACRO

config ZMK_KEYBOARD_NAME
    default "Pro Macropad"

endif # SHIELD_BTN_MACRO
```
